# IAR project Project.ewp, settings and files
configuration STM32F446RE-BlueCoin (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446RE ST STM32F446RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx; USE_STM32F4XX_NUCLEO; STM32_BLUECOIN; ARM_MATH_CM4; BLUENRG_MS
  ICCARM.CCDiagSuppress: Pa50
  ICCARM.CCIncludePath2: ..\..\..\..\..\Drivers\BSP\BlueCoin; ..\Inc; ..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO_CDC\Inc; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\Common_ex; ..\..\..\..\..\Drivers\BSP\Components\pcm1774; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Audio_SD.bin
  ILINK.IlinkOutputFile: BlueMS2_BC.out
  ILINK.IlinkIcfFile: stm32f446xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group AudioLoop/EWARM
    ./: startup_stm32f446xx.s
  group AudioLoop/User
    ../Src/: main.c sd_diskio.c stm32f4xx_hal_msp.c stm32f4xx_it.c usbd_audio_cdc_interface.c usbd_conf.c usbd_desc.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/BlueCoin
    ../../../../../Drivers/BSP/BlueCoin/: BlueCoin.c BlueCoin_audio.c BlueCoin_bus.c BlueCoin_sd.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/pcm1774/: PCM1774.c PCM1774_reg.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Middlewares/FatFs
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_IAR_wc32.a
  group Middlewares/STM32_USBD_Library
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO_CDC/Src/: usbd_audio_cdc.c
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
